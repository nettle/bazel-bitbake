## build/conf/layer.conf
```bitbake
BBPATH .= ":${LAYERDIR}"
BBFILES += "${LAYERDIR}/recipes/*.bb"
BBFILE_COLLECTIONS += "build"
BBFILE_PATTERN_build := "^${LAYERDIR}/recipes/"
```
